PACKAGECONFIG:append = " gtk"